LDFLAGS += "-Lout/yocto/${IOTIVITY_TARGET_ARCH}/release/ \
                  -lconnectivity_abstraction \
                  -loc \
                  -loc_logger"

